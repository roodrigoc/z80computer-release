# Repository roodrigoc/z80computer-release

File README.md:

# Kraft 80
A Z80-based computer for nostalgic enthusiasts\
©2025 - ARMCoder
UPDATED 2025 - October 12

<IMG SRC="https://github.com/ARMCoderBR/z80computer-release/blob/main/kraft80/kraft80-1.jpg?raw=true" width=600>

## Q & A

## What is this?

  For starters, this is no more than a hobby project: a Z80-based computer. By no means it aims to be a practical solution to anything, as any modern microcontroller can do much better with lower cost, lower complexity, lower power consumption and much more ease of use. You can eventually make changes on it to perform some practical automation tasks and it WILL work, it's just not recommended nowadays. Get a PIC or Arduino instead.

## Why did I build it?

  I began building a 3rd party kit called "Z80 Alpha" from a company called WR Kits here in Brazil. The kit was a box of parts (minus PCB), a set of manuals and a minimalistic monitor software.

  This was initially intended to be a quick pastime, but in time, I decided to expand the original kit with new features and write new software. See ALPHAPLUS-README.md for the historic background on that kit.

## What is the Kraft 80 computer, then?

It's a homebrew computer in development. This is the first Kraft 80's prototype:

<IMG SRC="https://github.com/ARMCoderBR/z80computer-release/blob/main/kraft80/kraft80-2.jpg?raw=true" width=600>

Then I've already built a first tentative true PCB for it, This one pictured here is the Rev 2.0:

<IMG SRC="https://github.com/ARMCoderBR/z80computer-release/blob/main/kraft80/IMG-20250930-WA0026.jpeg?raw=true" width=600>

There's a newer revision already designed and ordered (not delivered yet). This revision (called 2.2) fixes some mistakes and add some expansion connectors:

<IMG SRC="https://github.com/ARMCoderBR/z80computer-release/blob/main/kraft80/Captura%20de%20tela_2025-10-11_11-37-06.png?raw=true" width=600>
  
Characteristics:
```
  CPU:   Z80A, 4 MHz

  ROM BIOS + Monitor:  8 kbytes
  ROM BASIC: 8 kbytes

  RAM:   16 kbytes (disabled at boot) + 48 kbytes (the lower RAM can be remapped
         over the ROMs, yielding the full 64 kbytes ready for use)

  VIDEO: Text Mode: 48 rows x 80 columns - Monochrome
         Graphics Mode: 320x240 Framebuffer - 16 Color

  KEYBOARD: PS/2 compatible

  SOUND: Mono, compatible with GI AY3-891x (the famous so-called 'PSG' used in MSX computers and others from the 80s)

  TIMER Interrupt: Fixed, 300 Hz

  SERIAL: USB 19200 BPS, 8N1, RTS Flow control (via FTDI - USB chip)

  MICRO SD CARD CONTROLLER: Software still WIP, hardware already tested

  POWER: 5V 1A (via USB, the same of the FTDI above), or a separate Power connector (barrel P4 jack in PCB Rev 2.2)

  EXTRA IOS:
    LCD Alphanumeric 16x2
    8 Pushbuttons
    8 Controllable LEDs
    The Pushbuttons and LEDs also have corresponding expansion headers in PCB Rev 2.2.

```

What can the Kraft 80 currently do?
===================================

  Through its serial port, it can have software downloaded to its RAM. A serial monitor, 'Sysmon' (that runs on the BIOS ROM), is supplied for this purpose.

  Sysmon also has functions to edit and display the RAM contents using the PS/2 keyboard and monitor, or alternatively, through a serial terminal over the Serial 
port in the case you don't have a PS/2 keyboard or a spare VGA monitor.

  BASIC Interpreter: The ROM BASIC is the Microsoft BASIC 4.7b interpreter. There are two ROM images made available: the one that uses the BIOS, so the VGA output and the PS/2 keyboard are functional, and a standalone image that works only over the serial port. For those really nostalgic, there are some nice text-only games written in BASIC at this repository:

                    http://vintage-basic.net/games.html

  Remember that in order to switch ROM programs, the actual ROM chip needs to be replaced (and because of that, a ZIF socket is instrumental to keep the process smooth and safe!). 

  As the VGA controller is the latest addition to the Kraft80, not much software is available for it (yet). Currently, there's a clock demo (written in C) and I'm writing a Space Invaders clone (this one in pure Assembly). I'm planning to find out whether I can integrate graphics function into that BASIC interpreter!

Need more info?
===============

  You will find some other documentation in the project's directories. This part is still WIP, so please be patient and check every few days. New documentation is being added often.

## KiCad design kraft80/hardware/Kraft80V2.kicad_pcb

Parts:
C1, C2, C7, C10, C12, C15, C16, C18, C19, C90, C91: 100nF
C3: 33uF/16V
C6: 100uF/16V
C13: 10nF
C14: 47pF
CN1: +5VCC
D1: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D2: LED
JP1, JP2: Jumper_3_Bridged12
R1, R2, R3, R4, R5, R6: 10k
R7: 1k5
R16, R17: 1k
R18: 1M
R19: 5k6
RST1: SW_Push
U1: Z84C00xxP; DIP-40_W15.24mm
U2, U18: KM28C64A; DIP-28_W15.24mm
U4: 4093
U7: 74LS32
U9, U90: HM62256BLP; DIP-28_W15.24mm
U10: 74HC04
U91: 74LS138
U93: 74LS08
X1: 4MHz

Connections:
+5V: C1.1, C2.1, C6.1, C7.1, C10.1, C12.1, C15.1, C16.1, C18.1, C19.1, C90.1, C91.1, CN1.1, D1.1 (K), JP1.3 (B), JP2.1 (A), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R19.1, U1.11 (V_{CC}), U2.27 (~WE), U2.28 (VCC), U4.5, U9.28 (VCC), U18.27 (~WE), U18.28 (VCC), U90.28 (VCC), U91.6 (E3), U91.16 (VCC); also elsewhere on the board
/~MREQ: U1.19 (~MREQ), U7.10, U91.4 (E1)
/~ROM_BASIC: JP2.2 (C), U18.20 (~CE)
/~ROM_BIOS: U2.20 (~CE), U91.15 (O0)
/~SEL_RAM2: U7.8, U90.20 (~CS)
/~SEL_RAM: U9.20 (~CS), U93.6
A0: U1.30 (A_{0}), U2.10 (A0), U9.10 (A0), U18.10 (A0), U90.10 (A0); also elsewhere on the board
A1: U1.31 (A_{1}), U2.9 (A1), U9.9 (A1), U18.9 (A1), U90.9 (A1); also elsewhere on the board
A2: U1.32 (A_{2}), U2.8 (A2), U9.8 (A2), U18.8 (A2), U90.8 (A2); also elsewhere on the board
A3: U1.33 (A_{3}), U2.7 (A3), U9.7 (A3), U18.7 (A3), U90.7 (A3); also elsewhere on the board
A4: U1.34 (A_{4}), U2.6 (A4), U9.6 (A4), U18.6 (A4), U90.6 (A4); also elsewhere on the board
A5: U1.35 (A_{5}), U2.5 (A5), U9.5 (A5), U18.5 (A5), U90.5 (A5); also elsewhere on the board
A6: U1.36 (A_{6}), U2.4 (A6), U9.4 (A6), U18.4 (A6), U90.4 (A6); also elsewhere on the board
A7: U1.37 (A_{7}), U2.3 (A7), U9.3 (A7), U18.3 (A7), U90.3 (A7); also elsewhere on the board
A8: U1.38 (A_{8}), U2.25 (A8), U9.25 (A8), U18.25 (A8), U90.25 (A8)
A9: U1.39 (A_{9}), U2.24 (A9), U9.24 (A9), U18.24 (A9), U90.24 (A9)
A10: U1.40 (A_{10}), U2.21 (A10), U9.21 (A10), U18.21 (A10), U90.21 (A10)
A11: U1.1 (A_{11}), U2.23 (A11), U9.23 (A11), U18.23 (A11), U90.23 (A11)
A12: U1.2 (A_{12}), U2.2 (A12), U9.2 (A12), U18.2 (A12), U90.2 (A12)
A13: U1.3 (A_{13}), U9.26 (A13), U90.26 (A13), U91.1 (A0)
A14: U1.4 (A_{14}), U7.4, U9.1 (A14), U90.1 (A14)
A15: U1.5 (A_{15}), U10.9, U91.3 (A2)
CLOCK: R19.2, U1.6 (CLK), U10.12; also elsewhere on the board
CPM: U7.5; also elsewhere on the board
D0: U1.14 (D_{0}), U2.11 (I/O0), U9.11 (Q0), U18.11 (I/O0), U90.11 (Q0); also elsewhere on the board
D1: U1.15 (D_{1}), U2.12 (I/O1), U9.12 (Q1), U18.12 (I/O1), U90.12 (Q1); also elsewhere on the board
D2: U1.12 (D_{2}), U2.13 (I/O2), U9.13 (Q2), U18.13 (I/O2), U90.13 (Q2); also elsewhere on the board
D3: U1.8 (D_{3}), U2.15 (I/O3), U9.15 (Q3), U18.15 (I/O3), U90.15 (Q3); also elsewhere on the board
D4: U1.7 (D_{4}), U2.16 (I/O4), U9.16 (Q4), U18.16 (I/O4), U90.16 (Q4); also elsewhere on the board
D5: U1.9 (D_{5}), U2.17 (I/O5), U9.17 (Q5), U18.17 (I/O5), U90.17 (Q5); also elsewhere on the board
D6: U1.10 (D_{6}), U2.18 (I/O6), U9.18 (Q6), U18.18 (I/O6), U90.18 (Q6); also elsewhere on the board
D7: U1.13 (D_{7}), U2.19 (I/O7), U9.19 (Q7), U18.19 (I/O7), U90.19 (Q7); also elsewhere on the board
GNDREF: C1.2, C2.2, C3.2, C6.2, C7.2, C10.2, C12.2, C14.2, C15.2, C16.2, C18.2, C19.2, C90.2, C91.2, CN1.2, D2.1 (K), RST1.1, U1.29 (GND), U2.14 (GND), U9.14 (GND), U18.14 (GND), U90.14 (GND), U91.5 (E2), U91.8 (GND); also elsewhere on the board
unnamed: C13.1, R16.2, U10.2
unnamed: C13.2, R17.2, U10.3
unnamed: C14.1, R16.1, R18.1, U10.1, X1.1
unnamed: C3.1, D1.2 (A), R1.2, RST1.2, U4.1, U4.2
unnamed: D2.2 (A), R7.2
unnamed: JP1.1 (A), JP2.3 (B), U91.14 (O1)
unnamed: JP1.2 (C), U93.1
unnamed: R17.1, R18.2, U10.4, U10.5, X1.2
unnamed: R3.2, U1.25 (~BUSREQ)
unnamed: R6.2, U1.17 (~NMI)
unnamed: R4.2, U1.24 (~WAIT)
unnamed: U4.3, U4.6
unnamed: U7.9, U10.8
unnamed: U10.6, U10.13
unnamed: U7.6, U91.2 (A1)
unnamed: U91.13 (O2), U93.2
unnamed: U91.12 (O3), U93.5
unnamed: U93.3, U93.4
~INT: R5.2, U1.16 (~INT); also elsewhere on the board
~IORQ: U1.20 (~IORQ); also elsewhere on the board
~M1: U1.27 (~M1); also elsewhere on the board
~READ: U1.21 (~RD), U2.22 (~OE), U9.22 (~OE), U18.22 (~OE), U90.22 (~OE); also elsewhere on the board
~RESET: R2.2, U1.26 (~RESET), U4.4; also elsewhere on the board
~WRITE: U1.22 (~WR), U9.27 (~WE), U90.27 (~WE); also elsewhere on the board

Parts:
C4, C11: 100nF
C21: 10uF
J3: Speaker
J4: Mini-DIN-6
J9: Conn_01x06_Socket
Q1: BC337; TO-92_Inline
R20, R23, R24, R25, R26, R27, R28, R29, R30, R45, R46, R47, R48: 2k
R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59: 1k
R43: 22R
RV1: 10k
U8, U12: LVL-SHFT-8CH
U13: YP-8
U15, U16: 74HC595
U17: FTDI USB ADAPTER
U19: TANG NANO 9K

Connections:
+3V3: C4.1, C11.1, J9.5, U8.5 (LV), U12.5 (LV), U13.4 (Vout), U15.10 (~SRCLR), U15.16 (VCC), U16.10 (~SRCLR), U16.16 (VCC), U19.25 (+3V3)
+5V: J4.4, R39.1, R40.1, R43.1, U8.16 (HV), U12.16 (HV), U13.1 (Vin), U17.6 (5V); also elsewhere on the board
/kraft80V2-fpga/CK_KBD: J4.5, R40.2, U8.20 (HV1)
/kraft80V2-fpga/DAT_KBD: J4.1, R39.2, U8.11 (HV8)
/kraft80V2-fpga/DISK_MISO: J9.4, U19.4 (IOB33A)
/kraft80V2-fpga/DISK_MOSI: J9.3, U19.2 (IOB31A)
/kraft80V2-fpga/DISK_SCK: J9.2, U19.3 (IOB29B)
/kraft80V2-fpga/~DISK_CS: J9.1, U19.38 (IOT37B)
A0: R53.1; also elsewhere on the board
A1: R57.1; also elsewhere on the board
A2: R58.1; also elsewhere on the board
A3: R59.1; also elsewhere on the board
CLOCK: U8.14 (HV5); also elsewhere on the board
D0: U12.20 (HV1); also elsewhere on the board
D1: U12.19 (HV2); also elsewhere on the board
D2: U12.18 (HV3); also elsewhere on the board
D3: U12.17 (HV4); also elsewhere on the board
D4: U12.14 (HV5); also elsewhere on the board
D5: U12.13 (HV6); also elsewhere on the board
D6: U12.12 (HV7); also elsewhere on the board
D7: U12.11 (HV8); also elsewhere on the board
GNDREF: C4.2, C11.2, J4.3, J9.6, Q1.3 (E), R31.1, R49.2, R50.2, R51.2, R52.2, RV1.1, U8.6 (GND), U8.15 (GND), U12.6 (GND), U12.15 (GND), U13.2 (GND), U13.3 (GND), U15.8 (GND), U15.13 (~OE), U16.8 (GND), U16.13 (~OE), U17.9 (GND), U17.16 (GND), U19.26 (GND); also elsewhere on the board
unnamed: C21.1, R45.2, R54.2
unnamed: C21.2, RV1.3
unnamed: J3.1, R43.2
unnamed: J3.2, Q1.1 (C), R20.1
unnamed: Q1.2 (B), R20.2, RV1.2
unnamed: R23.2, R38.2, R41.1
unnamed: R24.2, R37.2, R38.1
unnamed: R25.2, R36.2, R37.1
unnamed: R26.2, R35.2, R36.1
unnamed: R27.2, R34.2, R35.1
unnamed: R28.2, R33.2, R34.1
unnamed: R29.2, R32.2, R33.1
unnamed: R30.2, R31.2, R32.1
unnamed: R41.2, R48.2, R56.1
unnamed: R46.2, R54.1, R55.2
unnamed: R47.2, R55.1, R56.2
unnamed: U12.1 (LV1), U19.15 (IOB41A)
unnamed: U12.2 (LV2), U19.16 (IOB41B)
unnamed: U12.3 (LV3), U19.17 (IOB17B)
unnamed: U12.4 (LV4), U19.18 (IOR15B)
unnamed: U12.7 (LV5), U19.19 (IOR15A)
unnamed: U12.8 (LV6), U19.20 (IOR14B)
unnamed: U12.9 (LV7), U19.21 (IOR14A)
unnamed: U12.10 (LV8), U19.22 (IOR13A)
unnamed: R27.1, U15.15 (QA)
unnamed: R28.1, U15.1 (QB)
unnamed: R29.1, U15.2 (QC)
unnamed: R30.1, U15.3 (QD)
unnamed: U15.12 (RCLK), U16.12 (RCLK), U19.27 (IOR15B)
unnamed: U15.14 (SER), U16.9 (QH')
unnamed: U15.11 (SRCLK), U16.11 (SRCLK), U19.28 (IOR15A)
unnamed: R45.1, U16.15 (QA)
unnamed: R46.1, U16.1 (QB)
unnamed: R47.1, U16.2 (QC)
unnamed: R48.1, U16.3 (QD)
unnamed: R23.1, U16.4 (QE)
unnamed: R24.1, U16.5 (QF)
unnamed: R25.1, U16.6 (QG)
unnamed: R26.1, U16.7 (QH)
unnamed: U16.14 (SER), U19.29 (IOR24A)
unnamed: U17.14 (RXD), U19.6 (IOB8B)
unnamed: U17.10 (TXD), U19.7 (IOB11A)
unnamed: U17.4 (~CTS), U19.48 (IOR5A)
unnamed: U8.1 (LV1), U19.5 (IOB8A)
unnamed: U8.2 (LV2), U19.8 (IOB11B)
unnamed: U8.3 (LV3), U19.9 (IOB13A)
unnamed: U8.4 (LV4), U19.10 (IOB13B)
unnamed: U8.7 (LV5), U19.11 (IOB23A)
unnamed: U8.8 (LV6), U19.12 (IOB23B)
unnamed: U8.10 (LV8), U19.14 (IOB29A)
unnamed: U8.9 (LV7), U19.13 (IOB33B)
unnamed: R49.1, R53.2, U19.43 (IOT11A)
unnamed: R50.1, R57.2, U19.42 (IOT11B)
unnamed: R51.1, R58.2, U19.41 (IOT12A)
unnamed: R52.1, R59.2, U19.40 (IOT12B)
~FPGA_CS: U8.13 (HV6); also elsewhere on the board
~INT: U8.12 (HV7); also elsewhere on the board
~READ: U8.18 (HV3); also elsewhere on the board
~RESET: U8.17 (HV4); also elsewhere on the board
~WRITE: U8.19 (HV2); also elsewhere on the board

Notes on the sheet:
LSB(First)
MSB(Last)
HDMI Video out
SD CARD SHIELD (DISK)
PS/2 KEYBOARD

Parts:
C5, C8, C9, C17, C20, C97, C99: 100nF
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: LED
LCD1: LCD16X2; LCD-016N002L
P1: 100k
R8, R9, R10, R11, R12, R13, R14, R15, R21, R22: 1k8
R44: 22
RN1: 10k; R_Array_SIP9
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8: SW_Push
U3: 74LS138
U4: 4093
U5, U11: 74LS273
U6: 74LS245
U7, U97: 74LS32
U10: 74HC04
U93: 74LS08
U99: 74LS74

Connections:
+5V: C5.1, C8.1, C9.1, C17.1, C20.1, C97.1, C99.1, LCD1.2 (VDD), P1.1, R44.1, RN1.1 (common), U3.16 (VCC), U4.8, U4.9, U4.12, U4.13, U4.14 (VCC), U5.20 (VCC), U6.20 (VCC), U7.1, U7.2, U7.12, U7.13, U7.14 (VCC), U10.11, U10.14 (VCC), U11.20 (VCC), U93.9, U93.10, U93.12, U93.13, U93.14 (VCC), U97.14 (VCC), U99.4 (~S), U99.10 (~S), U99.14 (VCC); also elsewhere on the board
/kraft80V2-ios/PX0: RN1.2 (R1), SW1.2, U6.18 (B0)
/kraft80V2-ios/PX1: RN1.3 (R2), SW2.2, U6.17 (B1)
/kraft80V2-ios/PX2: RN1.4 (R3), SW3.2, U6.16 (B2)
/kraft80V2-ios/PX3: RN1.5 (R4), SW4.2, U6.15 (B3)
/kraft80V2-ios/PX4: RN1.6 (R5), SW5.2, U6.14 (B4)
/kraft80V2-ios/PX5: RN1.7 (R6), SW6.2, U6.13 (B5)
/kraft80V2-ios/PX6: RN1.8 (R7), SW7.2, U6.12 (B6)
/kraft80V2-ios/PX7: RN1.9 (R8), SW8.2, U6.11 (B7)
/kraft80V2-ios/~DISP_CS: U3.14 (O1), U97.9
/kraft80V2-ios/~FF_CS: U3.11 (O4), U97.2
/kraft80V2-ios/~LEDKB_CS: U3.15 (O0), U97.4, U97.12
A4: U3.1 (A0); also elsewhere on the board
A5: U3.2 (A1); also elsewhere on the board
A6: U3.3 (A2); also elsewhere on the board
A7: U3.5 (E2); also elsewhere on the board
CKDIS: U11.11 (Cp), U97.8
CKFF: U97.3, U99.3 (C), U99.11 (C)
CKKBD: U6.19 (CE), U97.11
CKLED: U5.11 (Cp), U97.6
CPM: R21.1, U99.5 (Q); also elsewhere on the board
D0: U5.3 (D0), U6.2 (A0), U11.3 (D0), U99.2 (D); also elsewhere on the board
D1: U5.4 (D1), U6.3 (A1), U11.4 (D1), U99.12 (D); also elsewhere on the board
D2: U5.7 (D2), U6.4 (A2), U11.7 (D2); also elsewhere on the board
D3: U5.8 (D3), U6.5 (A3), U11.8 (D3); also elsewhere on the board
D4: U5.13 (D4), U6.6 (A4), U11.13 (D4); also elsewhere on the board
D5: U5.14 (D5), U6.7 (A5), U11.14 (D5); also elsewhere on the board
D6: U5.17 (D6), U6.8 (A6), U11.17 (D6); also elsewhere on the board
D7: U5.18 (D7), U6.9 (A7), U11.18 (D7); also elsewhere on the board
GNDREF: C5.2, C8.2, C9.2, C17.2, C20.2, C97.2, C99.2, D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), LCD1.1 (VSS), LCD1.5 (R/~W), LCD1.7 (DB0), LCD1.8 (DB1), LCD1.9 (DB2), LCD1.10 (DB3), LCD1.16 (K), P1.3, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, U3.8 (GND), U4.7 (GND), U5.10 (GND), U6.1 (A->B), U6.10 (GND), U7.7 (GND), U10.7 (GND), U11.10 (GND), U93.7 (GND), U97.7 (GND), U99.7 (GND); also elsewhere on the board
unnamed: D3.2 (A), R8.2
unnamed: D4.2 (A), R9.2
unnamed: D5.2 (A), R10.2
unnamed: D6.2 (A), R11.2
unnamed: D7.2 (A), R12.2
unnamed: D8.2 (A), R13.2
unnamed: D9.2 (A), R14.2
unnamed: D10.2 (A), R15.2
unnamed: D11.2 (A), R21.2
unnamed: D12.2 (A), R22.2
unnamed: LCD1.15 (A/VEE), R44.2
unnamed: LCD1.11 (DB4), U11.12 (Q4)
unnamed: LCD1.12 (DB5), U11.15 (Q5)
unnamed: LCD1.13 (DB6), U11.16 (Q6)
unnamed: LCD1.14 (DB7), U11.19 (Q7)
unnamed: LCD1.6 (E), U11.5 (Q1)
unnamed: LCD1.4 (RS), U11.2 (Q0)
unnamed: LCD1.3 (VO), P1.2
unnamed: R12.1, U5.2 (Q0)
unnamed: R13.1, U5.5 (Q1)
unnamed: R14.1, U5.6 (Q2)
unnamed: R15.1, U5.9 (Q3)
unnamed: R8.1, U5.12 (Q4)
unnamed: R9.1, U5.15 (Q5)
unnamed: R10.1, U5.16 (Q6)
unnamed: R11.1, U5.19 (Q7)
unnamed: R22.1, U99.9 (Q)
~FPGA_CS: U3.10 (O5); also elsewhere on the board
~IORQ: U3.4 (E1); also elsewhere on the board
~M1: U3.6 (E3); also elsewhere on the board
~READ: U97.13; also elsewhere on the board
~RESET: U5.1 (~Mr), U11.1 (~Mr), U99.1 (~R), U99.13 (~R); also elsewhere on the board
~WRITE: U97.1, U97.5, U97.10; also elsewhere on the board

Notes on the sheet:
PORTS: 00h - LEDS(W) & BUTTONS(R) 10h - LCD(W) 20h - 8251(RW) 30h - 8259A(RW) 40h - FFs(W) 50h - FPGA (VIDEO,SND,KBD)

Board: 2 copper layers, 150.6 x 171.7 mm, 139 parts (0 on the bottom side), 162 nets.

## Code that names these connections

File AlphaPlus/amon2_alphaplus/amon2.asm (part):

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read_keyb:
		in 		a,(PORTX)		;lê o conteúdo de PORTX 
		bit		7,a				;bit 7 ativo?
		jp		z,px7			;sim, desvia para label px7
		bit		6,a				;não, bit 6 ativo?
		jp		z,px6			;sim, desvia para label px6
		bit		5,a				;não, bit 5 ativo?
		jp		z,px5			;sim, desvia para label px5
		bit		4,a				;não, bit 4 ativo?
		jp		z,px4			;sim, desvia para label px4	
		bit		3,a				;bit 3 ativo?
		jp		z,px3			;sim, desvia para label px3
		bit		2,a				;não, bit 2 ativo?
		jp		z,px2			;sim, desvia para label px2
		bit		1,a				;não, bit 1 ativo?
		jp		z,px1			;sim, desvia para label px1
		bit		0,a				;não, bit 0 ativo?
		jp		z,px0			;sim, desvia para label px0
		ret 					;retorna, se nenhum botão estiver pressionado

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
## Commit log

2025-05-28 Release project.
2025-05-28 Updates.
2025-06-02 Diversas atualizações.
2025-06-02 Updating head comments in sources.
2025-06-08 Update Kraft80 files.
2025-06-10 Fixes on ROM Basic.
2025-06-10 Add Basic examples.
2025-06-19 Update Kraftmon to v1.3 and schematics fixes (no build changes).
2025-07-08 Lots of releases from Kraft80 scratch.
2025-07-09 Kraft80 build auxiliary files.
2025-07-10 File rename
2025-07-10 Kraftmon 1.3.2 and README.
2025-07-10 AlphaPlus - small file fixes.
2025-09-14 Reorganizing widespread project
2025-09-15 Cleanup
2025-09-15 New pictures.
2025-09-15 New README
2025-09-18 FPGA Video fix - BASIC standalone BIOS update
2025-09-18 New chiptune; several fixes in Video (FPGA and BIOS).
2025-09-19 Add document.
2025-09-23 BIOS and docs updates.
2025-09-23 Coretest2 update.
2025-09-24 Created Z80 Alpha and Alpha Plus PCB; Fixes missing resistors on Kraft80 PCB.
2025-09-24 Created Z80 Alpha and Alpha Plus PCB.
2025-09-24 Fixes missing resistors on Kraft80 PCB.
2025-09-26 Sysmon updates. AlphaPlus PCB update.
2025-09-30 Kraft80 PCB updates
2025-10-01 Kraft80 schematic fix (audio amp) and PCB update.
2025-10-12 PCB Rev 2.2 and gerbers updates (prototype PCBs ordered).
2025-10-12 Add pic
2025-10-12 Update README.md 2025-Oct-12
